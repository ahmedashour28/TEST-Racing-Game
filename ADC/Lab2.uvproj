# Keil uVision project Lab2.uvproj, settings and files
target HelloLaunchPad (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: HelloLaunchPad
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c startup.s adc_driver.c adc_driver.h
    ../: TM4C123GH6PM.h tm4c123gh6pmold.h
  group Object code
    ./: texas.o
